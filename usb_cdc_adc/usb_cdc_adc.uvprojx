# Keil uVision project usb_cdc_adc.uvprojx, settings and files
target app (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: usb_cdc_adc
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER
  c include: .\Source\app_src\inc;.\Source\stm32_src\inc
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group app_src
    ./Source/app_src/src/: main.c usbd_cdc_if.c L3GD20_interface.c termometer_interface.c
  group stm32_src
    ./Source/stm32_src/src/: stm32f4xx_hal_flash_ramfunc.c usb_device.c usbd_cdc.c usbd_conf.c usbd_core.c usbd_ctlreq.c usbd_desc.c usbd_ioreq.c
software components: CMSIS:CORE 4.1.0, Board Support:LED 1.0.0, Device:STM32Cube Framework:Classic 1.3.1, Device:STM32Cube HAL:ADC 1.3.1, Device:STM32Cube HAL:Common 1.3.1, Device:STM32Cube HAL:Cortex 1.3.1, Device:STM32Cube HAL:DMA 1.3.1, Device:STM32Cube HAL:DMA2D 1.3.1, Device:STM32Cube HAL:GPIO 1.3.1, Device:STM32Cube HAL:PCD 1.3.1, Device:STM32Cube HAL:PWR 1.3.1, Device:STM32Cube HAL:RCC 1.3.1, Device:STM32Cube HAL:SPI 1.3.1, Device:STM32Cube HAL:TIM 1.3.1, Device:Startup 2.3.1
